# IAR project audiofft_hardfloat.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32WG990F256 EnergyMicro EFM32WG990F256
  ICCARM.CCDefines: EFM32WG990F256; __FPU_PRESENT=1; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32WG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\emwin\inc; ..\..\..\..\common\drivers\emwin\Dk3750; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: audiofft_hardfloat.bin
  ILINK.IlinkOutputFile: audiofft_hardfloat.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32WG990F256.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\reptile\emwin\lib\emwin_IAR_CM4F.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256; __FPU_PRESENT=1; ARM_MATH_CM4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group BSP
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
  group Drivers
    ../../../../common/drivers/: dmactrl.c rtcdrv.c tftdirect.c tftspi.c
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_direct.c
  group DSP
    ../../../../../CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_rfft_f32.c arm_rfft_init_f32.c
    ../../../../../CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../../CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
  group emlib
    ../../../../../emlib/src/: em_adc.c em_assert.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_prs.c em_rtc.c em_system.c em_timer.c em_usart.c
  group Source
    ../: audiofft.c plot.c logo.c GUIConf.c GUI_X.c LCDConf.c GUIResource.c
