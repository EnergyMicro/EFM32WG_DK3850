# Keil uVision project emode.uvproj, settings and files
target emode (ARM-ADS)
  device: EFM32WG990F256 Energy Micro
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: emode
  AfterMake: fromelf.exe --bin --output obj\emode.bin obj\emode.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\EnergyMicro\EFM32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..;..\..\..\..\..\reptile\glib
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
  group BSP
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: rtcdrv.c tftamapped.c
  group Graphics
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
    ../../../../../reptile/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_ebi.c em_gpio.c em_usart.c em_rtc.c
  group Source
    ../: emode.c
