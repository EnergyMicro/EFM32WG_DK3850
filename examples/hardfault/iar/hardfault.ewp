# IAR project hardfault.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32WG990F256 EnergyMicro EFM32WG990F256
  ICCARM.CCDefines: EFM32WG990F256; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32WG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: hardfault.bin
  ILINK.IlinkOutputFile: hardfault.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32WG990F256.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256; DEBUG_EFM
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_ebi.c em_usart.c em_int.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c
  group Source
    ../: hardfault.c main.c
