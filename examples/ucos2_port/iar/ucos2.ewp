# IAR project ucos2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32WG990F256 EnergyMicro EFM32WG990F256
  ICCARM.CCDefines: EFM32WG990F256
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32WG\Include; ..\..\..\..\..\emlib\inc; ..\src\bsp; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\src\app; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\Micrium\uCOS-II\uc-cpu; ..\..\..\..\..\reptile\Micrium\uCOS-II\uc-lib; ..\..\..\..\..\reptile\Micrium\uCOS-II\ucos-ii\Source; ..\..\..\..\..\reptile\Micrium\uCOS-II\uc-cpu\ARM-Cortex-M4\IAR; ..\..\..\..\..\reptile\Micrium\uCOS-II\ucos-ii\Ports\ARM-Cortex-M4\Generic\IAR
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ucos2.bin
  ILINK.IlinkOutputFile: ucos2.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32WG990F256.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group APP
    ../src/app/: app.c app_hooks.c app_task_one.c app_task_two.c app_task_three.c
  group BSP-DVK
    ../src/bsp/: bsp-uart.c
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: retargettft.c retargetio.c
  group Graphics
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_int.c em_emu.c em_ebi.c em_gpio.c em_system.c em_usart.c
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
    ../../../../../reptile/Micrium/uCOS-II/startup/EFM32WG/iar/: startup_efm32wg.s
  group uC/CPU
    ../../../../../reptile/Micrium/uCOS-II/uc-cpu/: cpu_core.c
    ../../../../../reptile/Micrium/uCOS-II/uc-cpu/ARM-Cortex-M4/IAR/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../../../../../reptile/Micrium/uCOS-II/uc-lib/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-II
    ../../../../../reptile/Micrium/uCOS-II/ucos-ii/Source/: ucos_ii.c
    ../../../../../reptile/Micrium/uCOS-II/ucos-ii/Ports/ARM-Cortex-M4/Generic/IAR/: os_dbg.c os_cpu_c.c os_cpu_a.asm
